# Keil uVision project Project.uvprojx, settings and files
target STM3210E_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210E_EVAL +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../../../../Drivers/STM32F1xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM3210E_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Example/User
    ../Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c uart.c gpio.c tim.c lcd.c adc.c i2c.c array.c rc522.c rtc.c HX711.c Motor.c
  group Example/MDK-ARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f101xe.s
  group Doc
    ../: rfid-hx711-ad-eeprom-rtc.txt
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_uart.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_i2c.c stm32f1xx_ll_i2c.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_rtc.c stm32f1xx_hal_spi.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_pwr.c stm32f1xx_ll_pwr.c
software components: CMSIS:CORE 5.1.2
